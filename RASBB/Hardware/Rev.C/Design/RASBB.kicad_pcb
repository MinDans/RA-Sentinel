# Repository MinDans/RA-Sentinel (continued)

## KiCad design RASBB/Hardware/Rev.C/Design/RASBB.kicad_pcb (continued)

Schematic: RF_Transceiver.kicad_sch, RASBB

Parts:
C145, C149: 20p; C_0402_1005Metric; Mfr. Part # 0402N200J500CT; LCSC Part # C123468
C146, C147: 10uF; C_0402_1005Metric; Mfr. Part # 0402X106M100CT; LCSC Part # C2992625
C148, C152, C154: 100nF; C_0402_1005Metric; Mfr. Part # 0402B104K500CT; LCSC Part # C152814
C150, C151: 10nF; C_0402_1005Metric; Mfr. Part # 0402B103K500CT; LCSC Part # C301927
C153: 470nF; C_0402_1005Metric; Mfr. Part # GRT155R71A474KE01D; LCSC Part # C471404
C155: 0.8pF; C_0402_1005Metric; Mfr. Part # RF15N0R8B500CT; LCSC Part # C396870
C156, C158: 1.2pF; C_0402_1005Metric; Mfr. Part # 0402N1R2C500CT; LCSC Part # C301969
C157: 0.5pF; C_0402_1005Metric; Mfr. Part # RT15N0R5B500CT; LCSC Part # C2918554
C159: 100pF; C_0402_1005Metric; Mfr. Part # 0402N101G500CT; LCSC Part # C387967
FB3: BLM15BD601SH1D; NFZ15SG152SN10B; Mfr. Part # BLM15BD601SH1D; LCSC Part # C710334
IC13: SX1280IMLTRT; QFN50P400X400X100-25N-D; Mfr. Part # SX1280IMLTRT; LCSC Part # C125969
J11: Conn_Coaxial; U.FL_Hirose_U.FL-R-SMT-1_Vertical; Mfr. Part # CONUFL001-SMD-T or similar; LCSC Part # C22418213
L9: 3nH; L_0402_1005Metric; Mfr. Part # MHQ1005P3N0BT000; LCSC Part # C433005
L10: 2.5nH; L_0402_1005Metric; Mfr. Part # FHW0402UC2N5KST; LCSC Part # C317668
Y2: XC21M4-52.000-F10NNHPL; Mfr. Part # XC21M4-52.000-F10NNHPL; LCSC Part # C3034316

Connections:
+3V3: FB3.1; also elsewhere on the board
/RF_Transceiver/BUSY_LORA_G: IC13.7 (BUSY); also elsewhere on the board
/RF_Transceiver/DIO1_LORA_G: IC13.8 (DIO1); also elsewhere on the board
/RF_Transceiver/DIO2_LORA_G: IC13.9 (DIO2); also elsewhere on the board
/RF_Transceiver/DIO3_LORA_G: IC13.10 (DIO3); also elsewhere on the board
/RF_Transceiver/LORA_VDDIO: C146.1, C147.1, C148.1, C152.1, C154.1, FB3.2, IC13.11 (VBAT_IO), IC13.15 (VBAT)
/RF_Transceiver/NRST_LORA_G: IC13.3 (NRESET); also elsewhere on the board
/RF_Transceiver/SPI_MISO_LORA_G: IC13.16 (MISO_TX); also elsewhere on the board
/RF_Transceiver/SPI_MOSI_LORA_G: IC13.17 (MOSI_RX); also elsewhere on the board
/RF_Transceiver/SPI_NSS_LORA_G: IC13.19 (NSS_CTS); also elsewhere on the board
/RF_Transceiver/SPI_SCK_LORA_G: IC13.18 (SCK_RTSN); also elsewhere on the board
GND: C145.2, C146.2, C147.2, C148.2, C149.2, C150.2, C151.2, C152.2, C153.2, C154.2, C155.2, C156.2, C158.2, IC13.5 (GND_1), IC13.13 (GND_2), IC13.20 (GND_3), IC13.21 (GND_4), IC13.23 (GND_5), IC13.24 (GND_6), IC13.25 (EP), J11.2 (Ext), Y2.2 (GND_1), Y2.4 (GND_2); also elsewhere on the board
unnamed: C156.1, C157.1, L9.2, L10.1
unnamed: C157.2, C158.1, C159.2, L10.2
unnamed: C150.1, C153.1, IC13.2 (VDD_IN), IC13.12 (DCC_FB)
unnamed: C155.1, IC13.22 (RFIO), L9.1
unnamed: C151.1, IC13.1 (VR_PA)
unnamed: C149.1, IC13.4 (XTA), Y2.3 (XTAL_2)
unnamed: C145.1, IC13.6 (XTB), Y2.1 (XTAL_1)
unnamed: C159.1, J11.1 (In)

Schematic: Audio_IN-OUT.kicad_sch, RASBB

Parts:
C160, C161, C166: 10uF; C_0603_1608Metric; Mfr. Part # 0603X106M250CT; LCSC Part # C4555498
C162: 47nF; C_0402_1005Metric; Mfr. Part # C0402C473J8RAC7867; LCSC Part # C2178375
C163: 100pF; C_0402_1005Metric; Mfr. Part # 0402N101G500CT; LCSC Part # C387967
C164, C353: 100nF; C_0402_1005Metric; Mfr. Part # 0402B104K500CT; LCSC Part # C152814
C165: UUD1A221MCL1GS; CAPAE660X800N; Mfr. Part # UUD1A221MCL1GS; LCSC Part # C445275
C167: 1uF; C_0402_1005Metric; Mfr. Part # 0402X105M160CT; LCSC Part # C3889771
J12: AudioJack4; FC68128; Mfr. Part # HC-PJ-313E8-B-SMT; LCSC Part # C7501803
R67, R124: 10K; R_0402_1005Metric; Mfr. Part # WR04X1002FTL; LCSC Part # C163810
R121: 1.2K; R_0402_1005Metric; Mfr. Part # WR04X1201FTL; LCSC Part # C168197
R122: 10; R_0402_1005Metric; Mfr. Part # 0402WGF100JTCE; LCSC Part # C25077
R123: 51K; R_0603_1608Metric; Mfr. Part # WR06X5102FTL; LCSC Part # C227390
R125, R126: 100K; R_0402_1005Metric; Mfr. Part # RC0402FR-07100KL; LCSC Part # C60491; not fitted
R127: 5.6K; R_0402_1005Metric; Mfr. Part # WR04X5601FTL; LCSC Part # C168239
U8: LM386; SOP-8_3.9x4.9mm_P1.27mm; Mfr. Part # LM386D; LCSC Part # C510560
U9: LM321; SOT-23-5; Mfr. Part # LM321-TR; LCSC Part # C280706

Connections:
+3V3: C164.1, R67.2, R125.2, R127.1, U9.5 (V+); also elsewhere on the board
+5V: C353.1, U8.6 (V+); also elsewhere on the board
/Audio_IN-OUT/Audio_IN: C163.2, R123.2, U9.4; also elsewhere on the board
/Audio_IN-OUT/Audio_PTT: J12.4A (R1), J12.4B (R1), R67.1; also elsewhere on the board
/Audio_IN-OUT/LM386_INP: U8.3 (+); also elsewhere on the board
GND: C160.2, C162.2, C164.2, C353.2, J12.1A (S), J12.1B (S), R124.2, R126.1, U8.2 (-), U8.4 (GND), U9.2 (V-); also elsewhere on the board
unnamed: C161.1, U8.8 (GAIN)
unnamed: C161.2, R121.2
unnamed: C162.1, R122.1
unnamed: C165.1, R122.2, U8.5
unnamed: C165.2, J12.2A (T), J12.2B (T)
unnamed: C166.2, R124.1
unnamed: C167.2, J12.3A (R2), J12.3B (R2), R127.2
unnamed: R121.1, U8.1 (GAIN)
unnamed: C160.1, U8.7 (BYPASS)
unnamed: C167.1, R125.1, R126.2, U9.1 (+)
unnamed: C163.1, C166.1, R123.1, U9.3 (-)

Schematic: Interconnect.kicad_sch, RASBB

Parts:
C125, C256: 22uF; C_0603_1608Metric; Mfr. Part # 0603YD226MAT2A; LCSC Part # C6776252
J5: FH12-50S-0.5SV; CON50_1X50_DUTB_HRS_HIR; Mfr. Part # FH12-50S-0.5SVA(54); LCSC Part # C597991
RN1, RN2, RN3, RN4, RN5, RN6, RN7, RN8, RN9, RN10: CAY10-330J4LF; CAY10-XXXJ4; Mouser Part Number 652-CAY10-330J4LF

Connections:
+3V3: C125.2, C256.2, J5.1, J5.41; also elsewhere on the board
/DEBUG_A0_F: RN1.5; also elsewhere on the board
/DEBUG_A1_F: RN5.4; also elsewhere on the board
/DEBUG_A2_F: RN1.6; also elsewhere on the board
/DEBUG_A3_F: RN5.3; also elsewhere on the board
/DEBUG_A4_F: RN1.7; also elsewhere on the board
/DEBUG_A5_F: RN5.2; also elsewhere on the board
/DEBUG_A6_F: RN1.8; also elsewhere on the board
/DEBUG_A7_F: RN5.1; also elsewhere on the board
/DEBUG_D0_F: RN2.5; also elsewhere on the board
/DEBUG_D1_F: RN6.4; also elsewhere on the board
/DEBUG_D2_F: RN2.6; also elsewhere on the board
/DEBUG_D3_F: RN6.3; also elsewhere on the board
/DEBUG_D4_F: RN2.7; also elsewhere on the board
/DEBUG_D5_F: RN6.2; also elsewhere on the board
/DEBUG_D6_F: RN2.8; also elsewhere on the board
/DEBUG_D7_F: RN6.1; also elsewhere on the board
/DEBUG_D8_F: RN3.5; also elsewhere on the board
/DEBUG_D9_F: RN7.4; also elsewhere on the board
/DEBUG_D10_F: RN3.6; also elsewhere on the board
/DEBUG_D11_F: RN7.3; also elsewhere on the board
/DEBUG_D12_F: RN3.7; also elsewhere on the board
/DEBUG_D13_F: RN7.2; also elsewhere on the board
/DEBUG_D14_F: RN3.8; also elsewhere on the board
/DEBUG_D15_F: RN7.1; also elsewhere on the board
/DEBUG_D16_F: RN4.5; also elsewhere on the board
/DEBUG_D17_F: RN8.4; also elsewhere on the board
/DEBUG_D18_F: RN4.6; also elsewhere on the board
/DEBUG_D19_F: RN8.3; also elsewhere on the board
/DEBUG_D20_F: RN4.7; also elsewhere on the board
/DEBUG_D21_F: RN8.2; also elsewhere on the board
/DEBUG_D22_F: RN4.8; also elsewhere on the board
/DEBUG_D23_F: RN8.1; also elsewhere on the board
/DEBUG_D24_F: RN9.8; also elsewhere on the board
/DEBUG_D25_F: RN10.4; also elsewhere on the board
/DEBUG_D26_F: RN9.7; also elsewhere on the board
/DEBUG_D27_F: RN10.3; also elsewhere on the board
/DEBUG_D28_F: RN9.6; also elsewhere on the board
/DEBUG_D29_F: RN10.2; also elsewhere on the board
/DEBUG_D30_F: RN9.5; also elsewhere on the board
/DEBUG_D31_F: RN10.1; also elsewhere on the board
/Inteconnect/Debug_A0: J5.3, RN1.4
/Inteconnect/Debug_A1: J5.4, RN5.5
/Inteconnect/Debug_A2: J5.5, RN1.3
/Inteconnect/Debug_A3: J5.6, RN5.6
/Inteconnect/Debug_A4: J5.7, RN1.2
/Inteconnect/Debug_A5: J5.8, RN5.7
/Inteconnect/Debug_A6: J5.9, RN1.1
/Inteconnect/Debug_A7: J5.10, RN5.8
/Inteconnect/Debug_D0: J5.13, RN2.4
/Inteconnect/Debug_D1: J5.12, RN6.5
/Inteconnect/Debug_D2: J5.15, RN2.3
/Inteconnect/Debug_D3: J5.14, RN6.6
/Inteconnect/Debug_D4: J5.17, RN2.2
/Inteconnect/Debug_D5: J5.16, RN6.7
/Inteconnect/Debug_D6: J5.19, RN2.1
/Inteconnect/Debug_D7: J5.18, RN6.8
/Inteconnect/Debug_D8: J5.23, RN3.4
/Inteconnect/Debug_D9: J5.22, RN7.5
/Inteconnect/Debug_D10: J5.25, RN3.3
/Inteconnect/Debug_D11: J5.24, RN7.6
/Inteconnect/Debug_D12: J5.27, RN3.2
/Inteconnect/Debug_D13: J5.26, RN7.7
/Inteconnect/Debug_D14: J5.29, RN3.1
/Inteconnect/Debug_D15: J5.28, RN7.8
/Inteconnect/Debug_D16: J5.33, RN4.4
/Inteconnect/Debug_D17: J5.32, RN8.5
/Inteconnect/Debug_D18: J5.35, RN4.3
/Inteconnect/Debug_D19: J5.34, RN8.6
/Inteconnect/Debug_D20: J5.37, RN4.2
/Inteconnect/Debug_D21: J5.36, RN8.7
/Inteconnect/Debug_D22: J5.39, RN4.1
/Inteconnect/Debug_D23: J5.38, RN8.8
/Inteconnect/Debug_D24: J5.43, RN9.4
/Inteconnect/Debug_D25: J5.42, RN10.5
/Inteconnect/Debug_D26: J5.45, RN9.3
/Inteconnect/Debug_D27: J5.44, RN10.6
/Inteconnect/Debug_D28: J5.47, RN9.2
/Inteconnect/Debug_D29: J5.46, RN10.7
/Inteconnect/Debug_D30: J5.49, RN9.1
/Inteconnect/Debug_D31: J5.48, RN10.8
GND: C125.1, C256.1, J5.2, J5.11, J5.20, J5.21, J5.30, J5.31, J5.40, J5.50; also elsewhere on the board

Schematic: FPGA2_BANK35.kicad_sch, RASBB

Parts:
C199: 100uF; C_1206_3216Metric; Mfr. Part # GRM31CR61A107MEA8L; LCSC Part # C883598
C342: 100nF; C_0402_1005Metric; Mfr. Part # 0402B104K500CT; LCSC Part # C152814
C346, C347, C348, C349: 470nF; C_0402_1005Metric; Mfr. Part # GRT155R71A474KE01D; LCSC Part # C471404
C350, C351: 4.7uF; C_0402_1005Metric; Mfr. Part # GRM155R61A475KEAAD; LCSC Part # C77004
J18: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical; Mfr. Part # PZ254V-11-02P; LCSC Part # C492401
R72, R166, R167: 49.9; R_0402_1005Metric; Mfr. Part # RMCF0402FT49R9; LCSC Part # C4229190
U11: XC7A100T-CSG324; BGA324C80P18X18_1500X1500X150; Mfr. Part # XC7A100T-2CSG324I; LCSC Part # C1521791
X4: OT2EL4C4JI-111OLP-50M; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm; Mfr. Part # OT2EL4C4JI-111OLP-50M; LCSC Part # C5203552

Connections:
+3V3: C199.1, C346.1, C347.1, C348.1, C349.1, C350.1, C351.1, R72.2, U11.A7 (VCCO_35), U11.C3 (VCCO_35), U11.D6 (VCCO_35), U11.F2 (VCCO_35), U11.G5 (VCCO_35), U11.J1 (VCCO_35); also elsewhere on the board
/Ethernet_FPGA/G_ETH_RESET: U11.A3 (IO_L8N_T1_AD14N_35); also elsewhere on the board
/Ethernet_FPGA/RGMII_MDC: U11.A1 (IO_L9N_T1_DQS_AD7N_35); also elsewhere on the board
/Ethernet_FPGA/RGMII_MDIO: U11.B1 (IO_L9P_T1_DQS_AD7P_35); also elsewhere on the board
/Ethernet_FPGA/RGMII_RXC: U11.E1 (IO_L18N_T2_35); also elsewhere on the board
/Ethernet_FPGA/RGMII_RXD0: U11.C1 (IO_L16N_T2_35); also elsewhere on the board
/Ethernet_FPGA/RGMII_RXD1: U11.C2 (IO_L16P_T2_35); also elsewhere on the board
/Ethernet_FPGA/RGMII_RXD2: U11.D2 (IO_L14N_T2_SRCC_35); also elsewhere on the board
/Ethernet_FPGA/RGMII_RXD3: U11.E2 (IO_L14P_T2_SRCC_35); also elsewhere on the board
/Ethernet_FPGA/RGMII_RXDV: U11.B3 (IO_L10P_T1_AD15P_35); also elsewhere on the board
/Ethernet_FPGA/RGMII_TXC: U11.F4 (IO_L13P_T2_MRCC_35); also elsewhere on the board
/Ethernet_FPGA/RGMII_TXD0: U11.F1 (IO_L18P_T2_35); also elsewhere on the board
/Ethernet_FPGA/RGMII_TXD1: U11.G1 (IO_L17N_T2_35); also elsewhere on the board
/Ethernet_FPGA/RGMII_TXD2: U11.H1 (IO_L17P_T2_35); also elsewhere on the board
/Ethernet_FPGA/RGMII_TXD3: U11.H2 (IO_L15P_T2_DQS_35); also elsewhere on the board
/Ethernet_FPGA/RGMII_TX_EN: U11.G2 (IO_L15N_T2_DQS_35); also elsewhere on the board
/FPGA-02/F2_B35_J2: U11.J2 (IO_L22N_T3_35); also elsewhere on the board
GND: C199.2, C342.2, C346.2, C347.2, C348.2, C349.2, C350.2, C351.2, J18.2, X4.2 (GND); also elsewhere on the board
unnamed: J18.1, R167.1
unnamed: R167.2, U11.D3 (IO_L12N_T1_MRCC_35)
unnamed: R166.2, U11.E3 (IO_L12P_T1_MRCC_35)
unnamed: C342.1, R72.1, X4.1 (EN), X4.4 (Vdd)
unnamed: R166.1, X4.3 (OUT)

Notes on the sheet:
Clock Test Output

Schematic: FPGA2_BANK0.kicad_sch, RASBB

Parts:
C202: 100nF; C_0402_1005Metric; Mfr. Part # 0402B104K500CT; LCSC Part # C152814
C305: 47uF; C_0805_2012Metric; Mfr. Part # GRM21BR61A476ME15L; LCSC Part # C124129
C306: 470nF; C_0402_1005Metric; Mfr. Part # GRT155R71A474KE01D; LCSC Part # C471404
D12: DT2042-04SO-7; SOT95P285X140-6N; Mfr. Part # DT2042-04SO-7; LCSC Part # C2841428
D14, D16: A-SP192YR6C-C01-4T; LED_0603_1608Metric; Mfr. Part # A-SP192YR6C-C01-4T; LCSC Part # C5355433
J15: Conn_01x06_Socket; PinHeader_2x03_P1.27mm_Vertical_SMD; Mfr. Part # ZX-PZ1.27-2-3PWZ; LCSC Part # C41370771
R56, R103, R207: 4K7; R_0402_1005Metric; Mfr. Part # RC0402FR-074K7L; LCSC Part # C105871
R160, R161, R162, R163: 49.9; R_0402_1005Metric; Mfr. Part # RMCF0402FT49R9; LCSC Part # C4229190
R164: 10K; R_0402_1005Metric; Mfr. Part # WR04X1002FTL; LCSC Part # C163810
R206: 1.5K; R_0402_1005Metric; Mfr. Part # WR04X152JTL; LCSC Part # C384376
S3: B3FS-1002P; B3FS-1000P; Mfr. Part # B3FS-1002P; LCSC Part # C271750
U11: XC7A100T-CSG324; BGA324C80P18X18_1500X1500X150; Mfr. Part # XC7A100T-2CSG324I; LCSC Part # C1521791

Connections:
+3V3: C202.2, C305.1, C306.1, J15.6 (VCC), R56.1, R103.1, R164.1, R206.1, R207.1, U11.P8 (CFGBVS_0), U11.P12 (M0_0), U11.R9 (VCCO_0); also elsewhere on the board
/FPGA-02/BANK0/FPGA2_DONE: D14.1 (K), R206.2, U11.P10 (DONE_0); also elsewhere on the board
/FPGA-02/BANK0/FPGA2_INIT: D16.1 (K), R207.2, U11.P7 (INIT_B_0)
/FPGA-02/BANK0/FPGA2_TDO: R162.2, U11.E13 (TDO_0)
/FPGA-02/BANK0/JTAG2_TCK: R163.2, U11.E10 (TCK_0)
/FPGA-02/BANK0/JTAG2_TDI: R161.2, U11.E11 (TDI_0)
/FPGA-02/BANK0/JTAG2_TMS: R160.2, U11.E12 (TMS_0)
/FPGA-02/BANK0/TCK_2: D12.6 (I/O4), J15.4 (TCK_2), R163.1
/FPGA-02/BANK0/TDI_2: D12.4 (I/O3), J15.2 (TDI_2), R161.1
/FPGA-02/BANK0/TDO_2: D12.1 (I/O1), J15.3 (TDO_2), R162.1
/FPGA-02/BANK0/TMS_2: D12.3 (I/O2), J15.1 (TMS_2), R160.1
/FPGA-02/FPGA2_PROG: R164.2, S3.3 (B), S3.4 (B), U11.P9 (PROGRAM_B_0); also elsewhere on the board
/SCK_FLASH_FPGA2: U11.E9 (CCLK_0); also elsewhere on the board
GND: C202.1, C305.2, C306.2, D12.2 (VSS), J15.5 (GND), S3.1 (A), S3.2 (A), U11.J9 (VREFN_0), U11.J10 (VP_0), U11.K9 (VN_0), U11.K10 (VREFP_0), U11.L9 (DXN_0), U11.L10 (DXP_0), U11.P11 (M2_0), U11.P13 (M1_0); also elsewhere on the board
unnamed: D14.2 (A), R56.2
unnamed: D16.2 (A), R103.2

Schematic: FPGA2_BANK16-34.kicad_sch, RASBB

Parts:
C307, C311, C312: 4.7uF; C_0402_1005Metric; Mfr. Part # GRM155R61A475KEAAD; LCSC Part # C77004
C308, C313, C314, C315, C316: 470nF; C_0402_1005Metric; Mfr. Part # GRT155R71A474KE01D; LCSC Part # C471404
C310: 100uF; C_1206_3216Metric; Mfr. Part # GRM31CR61A107MEA8L; LCSC Part # C883598
C317: 47nF; C_0402_1005Metric; Mfr. Part # C0402C473J8RAC7867; LCSC Part # C2178375
U11: XC7A100T-CSG324; BGA324C80P18X18_1500X1500X150; Mfr. Part # XC7A100T-2CSG324I; LCSC Part # C1521791

Connections:
+1V8: C307.1, C308.1, U11.B10 (VCCO_16); also elsewhere on the board
+1V35: C310.1, C311.1, C312.1, C313.1, C314.1, C315.1, C316.1, C317.1, U11.K4 (VCCO_34), U11.N3 (VCCO_34), U11.P6 (VCCO_34), U11.T2 (VCCO_34), U11.U5 (VCCO_34), U11.V8 (VCCO_34); also elsewhere on the board
/DDR3-2/CK_N: U11.V9 (IO_L21N_T3_DQS_34); also elsewhere on the board
/DDR3-2/CK_P: U11.U9 (IO_L21P_T3_DQS_34); also elsewhere on the board
/DDR3-2/DDR301_A0: U11.R2 (IO_L15N_T2_DQS_34); also elsewhere on the board
/DDR3-2/DDR301_A1: U11.M6 (IO_L18P_T2_34); also elsewhere on the board
/DDR3-2/DDR301_A2: U11.N4 (IO_L16N_T2_34); also elsewhere on the board
/DDR3-2/DDR301_A3: U11.T1 (IO_L17N_T2_34); also elsewhere on the board
/DDR3-2/DDR301_A4: U11.N6 (IO_L18N_T2_34); also elsewhere on the board
/DDR3-2/DDR301_A5: U11.R7 (IO_L23P_T3_34); also elsewhere on the board
/DDR3-2/DDR301_A6: U11.V6 (IO_L20N_T3_34); also elsewhere on the board
/DDR3-2/DDR301_A7: U11.U7 (IO_L22P_T3_34); also elsewhere on the board
/DDR3-2/DDR301_A8: U11.R8 (IO_L24P_T3_34); also elsewhere on the board
/DDR3-2/DDR301_A9: U11.V7 (IO_L20P_T3_34); also elsewhere on the board
/DDR3-2/DDR301_A10/AP: U11.R6 (IO_L19P_T3_34); also elsewhere on the board
/DDR3-2/DDR301_A11: U11.U6 (IO_L22N_T3_34); also elsewhere on the board
/DDR3-2/DDR301_A12/nBC: U11.T6 (IO_L23N_T3_34); also elsewhere on the board
/DDR3-2/DDR301_A13: U11.T8 (IO_L24N_T3_34); also elsewhere on the board
/DDR3-2/DDR301_A14: U11.T5 (IO_L12P_T1_MRCC_34); also elsewhere on the board
/DDR3-2/DDR301_BA0: U11.R1 (IO_L17P_T2_34); also elsewhere on the board
/DDR3-2/DDR301_BA1: U11.P4 (IO_L14P_T2_SRCC_34); also elsewhere on the board
/DDR3-2/DDR301_BA2: U11.P2 (IO_L15P_T2_DQS_34); also elsewhere on the board
/DDR3-2/DDR301_CLKE: U11.N5 (IO_L13P_T2_MRCC_34); also elsewhere on the board
/DDR3-2/DDR301_DQ0: U11.K5 (IO_L5P_T0_34); also elsewhere on the board
/DDR3-2/DDR301_DQ1: U11.L3 (IO_L2N_T0_34); also elsewhere on the board
/DDR3-2/DDR301_DQ2: U11.K3 (IO_L2P_T0_34); also elsewhere on the board
/DDR3-2/DDR301_DQ3: U11.L6 (IO_L6P_T0_34); also elsewhere on the board
/DDR3-2/DDR301_DQ4: U11.M3 (IO_L4P_T0_34); also elsewhere on the board
/DDR3-2/DDR301_DQ5: U11.M1 (IO_L1N_T0_34); also elsewhere on the board
/DDR3-2/DDR301_DQ6: U11.L4 (IO_L5N_T0_34); also elsewhere on the board
/DDR3-2/DDR301_DQ7: U11.M2 (IO_L4N_T0_34); also elsewhere on the board
/DDR3-2/DDR301_DQ8: U11.V4 (IO_L10N_T1_34); also elsewhere on the board
/DDR3-2/DDR301_DQ9: U11.T4 (IO_L12N_T1_MRCC_34); also elsewhere on the board
/DDR3-2/DDR301_DQ10: U11.U4 (IO_L8P_T1_34); also elsewhere on the board
/DDR3-2/DDR301_DQ11: U11.V5 (IO_L10P_T1_34); also elsewhere on the board
/DDR3-2/DDR301_DQ12: U11.V1 (IO_L7N_T1_34); also elsewhere on the board
/DDR3-2/DDR301_DQ13: U11.T3 (IO_L11N_T1_SRCC_34); also elsewhere on the board
/DDR3-2/DDR301_DQ14: U11.U3 (IO_L8N_T1_34); also elsewhere on the board
/DDR3-2/DDR301_DQ15: U11.R3 (IO_L11P_T1_SRCC_34); also elsewhere on the board
/DDR3-2/DDR301_LDM: U11.L1 (IO_L1P_T0_34); also elsewhere on the board
/DDR3-2/DDR301_LDQS_N: U11.N1 (IO_L3N_T0_DQS_34); also elsewhere on the board
/DDR3-2/DDR301_LDQS_P: U11.N2 (IO_L3P_T0_DQS_34); also elsewhere on the board
/DDR3-2/DDR301_ODT: U11.R5 (IO_L19N_T3_VREF_34); also elsewhere on the board
/DDR3-2/DDR301_UDM: U11.U1 (IO_L7P_T1_34); also elsewhere on the board
/DDR3-2/DDR301_UDQS_N: U11.V2 (IO_L9N_T1_DQS_34); also elsewhere on the board
/DDR3-2/DDR301_UDQS_P: U11.U2 (IO_L9P_T1_DQS_34); also elsewhere on the board
/DDR3-2/DDR301_nCAS: U11.M4 (IO_L16P_T2_34); also elsewhere on the board
/DDR3-2/DDR301_nCS: U11.U8 (IO_25_34); also elsewhere on the board
/DDR3-2/DDR301_nRAS: U11.P3 (IO_L14N_T2_SRCC_34); also elsewhere on the board
/DDR3-2/DDR301_nRST: U11.K6 (IO_0_34); also elsewhere on the board
/DDR3-2/DDR301_nWE: U11.P5 (IO_L13N_T2_MRCC_34); also elsewhere on the board
GND: C307.2, C308.2, C310.2, C311.2, C312.2, C313.2, C314.2, C315.2, C316.2, C317.2; also elsewhere on the board

Schematic: FPGA2_PWR.kicad_sch, RASBB

Parts:
C187: 47uF; C_0805_2012Metric; Mfr. Part # GRM21BR61A476ME15L; LCSC Part # C124129
C269, C273, C274, C275, C277, C278, C280, C281, C284, C285, C287, C289, C291, C293: 470nF; C_0402_1005Metric; Mfr. Part # GRT155R71A474KE01D; LCSC Part # C471404
C282, C302, C303, C304: 100uF; C_1206_3216Metric; Mfr. Part # GRM31CR61A107MEA8L; LCSC Part # C883598
C290, C292, C294, C295, C296, C297, C298, C299, C300, C301: 4.7uF; C_0402_1005Metric; Mfr. Part # GRM155R61A475KEAAD; LCSC Part # C77004
U11: XC7A100T-CSG324; BGA324C80P18X18_1500X1500X150; Mfr. Part # XC7A100T-2CSG324I; LCSC Part # C1521791

Connections:
+1V0: C269.1, C273.1, C274.1, C277.1, C278.1, C281.1, C282.1, C285.1, C289.1, C291.1, C293.1, C295.1, C296.1, C297.1, C298.1, C299.1, C300.1, C301.1, C302.1, C303.1, C304.1, U11.F8 (VCCINT), U11.F10 (VCCBRAM), U11.G7 (VCCINT), U11.G9 (VCCINT), U11.G11 (VCCBRAM), U11.H8 (VCCINT), U11.J7 (VCCINT), U11.J11 (VCCINT), U11.K8 (VCCINT), U11.L7 (VCCINT), U11.L11 (VCCINT), U11.M8 (VCCINT), U11.M10 (VCCINT), U11.N7 (VCCINT), U11.N9 (VCCINT), U11.N11 (VCCINT); also elsewhere on the board
+1V8: C187.1, C275.1, C280.1, C284.1, C287.1, C290.1, C292.1, C294.1, U11.E8 (VCCBATT_0), U11.F12 (VCCAUX), U11.H10 (VCCADC_0), U11.H12 (VCCAUX), U11.K12 (VCCAUX), U11.M12 (VCCAUX); also elsewhere on the board
GND: C187.2, C269.2, C273.2, C274.2, C275.2, C277.2, C278.2, C280.2, C281.2, C282.2, C284.2, C285.2, C287.2, C289.2, C290.2, C291.2, C292.2, C293.2, C294.2, C295.2, C296.2, C297.2, C298.2, C299.2, C300.2, C301.2, C302.2, C303.2, C304.2, U11.A2 (GND), U11.A12 (GND), U11.B5 (GND), U11.B15 (GND), U11.C8 (GND), U11.C18 (GND), U11.D1 (GND), U11.D11 (GND), U11.E4 (GND), U11.E14 (GND), U11.F7 (GND), U11.F9 (GND), U11.F11 (GND), U11.F17 (GND), U11.G8 (GND), U11.G10 (GND), U11.G12 (GND), U11.H3 (GND), U11.H7 (GND), U11.H9 (GNDADC_0), U11.H11 (GND), U11.H13 (GND), U11.J6 (GND), U11.J8 (GND), U11.J12 (GND), U11.J16 (GND), U11.K7 (GND), U11.K11 (GND), U11.L2 (GND), U11.L8 (GND), U11.L12 (GND), U11.M5 (GND), U11.M7 (GND), U11.M9 (GND), U11.M11 (GND), U11.M15 (GND), U11.N8 (GND), U11.N10 (GND), U11.N12 (GND), U11.N18 (GND), U11.P1 (GND), U11.R4 (GND), U11.R14 (GND), U11.T7 (GND), U11.T17 (GND), U11.U10 (GND), U11.V3 (GND), U11.V13 (GND); also elsewhere on the board

Schematic: FPGA2_BANK14-15.kicad_sch, RASBB

Parts:
C195, C332: 100uF; C_1206_3216Metric; Mfr. Part # GRM31CR61A107MEA8L; LCSC Part # C883598
C326, C327, C328, C329, C335, C336, C337, C338: 470nF; C_0402_1005Metric; Mfr. Part # GRT155R71A474KE01D; LCSC Part # C471404
C330, C331, C333, C334: 4.7uF; C_0402_1005Metric; Mfr. Part # GRM155R61A475KEAAD; LCSC Part # C77004
C339: 47nF; C_0402_1005Metric; Mfr. Part # C0402C473J8RAC7867; LCSC Part # C2178375
D22: A-SP192DGHC-C01-4T; LED_0603_1608Metric; Mfr. Part # A-SP192DGHC-C01-4T; LCSC Part # C19171301
D23: A-SP192GS1D-C01-4T; LED_0603_1608Metric; Mfr. Part # A-SP192GS1D-C01-4T; LCSC Part # C5355434
R146, R147: 1K; R_0402_1005Metric; Mfr. Part # MR04X1001FTL; LCSC Part # C327796
U11: XC7A100T-CSG324; BGA324C80P18X18_1500X1500X150; Mfr. Part # XC7A100T-2CSG324I; LCSC Part # C1521791

Connections:
+3V3: C195.1, C326.1, C327.1, C328.1, C329.1, C330.1, C331.1, C332.1, C333.1, C334.1, C335.1, C336.1, C337.1, C338.1, C339.1, U11.A17 (VCCO_15), U11.C13 (VCCO_15), U11.D16 (VCCO_15), U11.G15 (VCCO_15), U11.H18 (VCCO_15), U11.K14 (VCCO_15), U11.L17 (VCCO_14), U11.N13 (VCCO_14), U11.P16 (VCCO_14), U11.T12 (VCCO_14), U11.U15 (VCCO_14), U11.V18 (VCCO_14); also elsewhere on the board
/CLK_OVR_ETH: U11.L16 (IO_L3N_T0_DQS_EMCCLK_14); also elsewhere on the board
/CS2_FLASH_uC: U11.U18 (IO_L17N_T2_A13_D29_14); also elsewhere on the board
/CS_FLASH_FPGA2: U11.L13 (IO_L6P_T0_FCS_B_14); also elsewhere on the board
/DEBUG_A0_F: U11.F15 (IO_L14P_T2_SRCC_15); also elsewhere on the board
/DEBUG_A1_F: U11.H17 (IO_L18P_T2_A24_15); also elsewhere on the board
/DEBUG_A2_F: U11.G18 (IO_L22P_T3_A17_15); also elsewhere on the board
/DEBUG_A3_F: U11.H16 (IO_L13P_T2_MRCC_15); also elsewhere on the board
/DEBUG_A4_F: U11.F16 (IO_L14N_T2_SRCC_15); also elsewhere on the board
/DEBUG_A5_F: U11.H15 (IO_L19N_T3_A21_VREF_15); also elsewhere on the board
/DEBUG_A6_F: U11.E15 (IO_L11P_T1_SRCC_15); also elsewhere on the board
/DEBUG_A7_F: U11.H14 (IO_L15P_T2_DQS_15); also elsewhere on the board
/DEBUG_D0_F: U11.E16 (IO_L11N_T1_SRCC_15); also elsewhere on the board
/DEBUG_D1_F: U11.G13 (IO_0_15); also elsewhere on the board
/DEBUG_D2_F: U11.E18 (IO_L21P_T3_DQS_15); also elsewhere on the board
/DEBUG_D3_F: U11.K16 (IO_25_15); also elsewhere on the board
/DEBUG_D4_F: U11.G17 (IO_L18N_T2_A23_15); also elsewhere on the board
/DEBUG_D5_F: U11.G14 (IO_L15N_T2_DQS_ADV_B_15); also elsewhere on the board
/DEBUG_D6_F: U11.E17 (IO_L16P_T2_A28_15); also elsewhere on the board
/DEBUG_D7_F: U11.G16 (IO_L13N_T2_MRCC_15); also elsewhere on the board
/DEBUG_D8_F: U11.D17 (IO_L16N_T2_A27_15); also elsewhere on the board
/DEBUG_D9_F: U11.A11 (IO_L4N_T0_15); also elsewhere on the board
/DEBUG_D10_F: U11.D15 (IO_L12P_T1_MRCC_15); also elsewhere on the board
/DEBUG_D11_F: U11.B11 (IO_L4P_T0_15); also elsewhere on the board
/DEBUG_D12_F: U11.D14 (IO_L1P_T0_AD0P_15); also elsewhere on the board
/DEBUG_D13_F: U11.C12 (IO_L3P_T0_DQS_AD1P_15); also elsewhere on the board
/DEBUG_D14_F: U11.F18 (IO_L22N_T3_A16_15); also elsewhere on the board
/DEBUG_D15_F: U11.B12 (IO_L3N_T0_DQS_AD1N_15); also elsewhere on the board
/DEBUG_D16_F: U11.D18 (IO_L21N_T3_DQS_A18_15); also elsewhere on the board
/DEBUG_D17_F: U11.A13 (IO_L9P_T1_DQS_AD3P_15); also elsewhere on the board
/DEBUG_D18_F: U11.B18 (IO_L10P_T1_AD11P_15); also elsewhere on the board
/DEBUG_D19_F: U11.D12 (IO_L6P_T0_15); also elsewhere on the board
/DEBUG_D20_F: U11.B17 (IO_L7N_T1_AD2N_15); also elsewhere on the board
/DEBUG_D21_F: U11.B13 (IO_L2P_T0_AD8P_15); also elsewhere on the board
/DEBUG_D22_F: U11.A18 (IO_L10N_T1_AD11N_15); also elsewhere on the board
/DEBUG_D23_F: U11.A14 (IO_L9N_T1_DQS_AD3N_15); also elsewhere on the board
/DEBUG_D24_F: U11.A16 (IO_L8N_T1_AD10N_15); also elsewhere on the board
/DEBUG_D25_F: U11.D13 (IO_L6N_T0_VREF_15); also elsewhere on the board
/DEBUG_D26_F: U11.B16 (IO_L7P_T1_AD2P_15); also elsewhere on the board
/DEBUG_D27_F: U11.B14 (IO_L2N_T0_AD8N_15); also elsewhere on the board
/DEBUG_D28_F: U11.C15 (IO_L12N_T1_MRCC_15); also elsewhere on the board
/DEBUG_D29_F: U11.A15 (IO_L8P_T1_AD10P_15); also elsewhere on the board
/DEBUG_D30_F: U11.C16 (IO_L20P_T3_A20_15); also elsewhere on the board
/DEBUG_D31_F: U11.C14 (IO_L1N_T0_AD0N_15); also elsewhere on the board
/FPGA2_RESET: U11.C17 (IO_L20N_T3_A19_15); also elsewhere on the board
/FPGA-02/F2_B14_P15: U11.P15 (IO_L13P_T2_MRCC_14); also elsewhere on the board
/FPGA-02/F2_B14_R15: U11.R15 (IO_L13N_T2_MRCC_14); also elsewhere on the board
/FPGA-02/F2_B14_R16: U11.R16 (IO_L15P_T2_DQS_RDWR_B_14); also elsewhere on the board
/FPGA-02/F2_B14_T15: U11.T15 (IO_L14N_T2_SRCC_14); also elsewhere on the board
/FPGA-02/F2_B14_T16: U11.T16 (IO_L15N_T2_DQS_DOUT_CSO_B_14); also elsewhere on the board
/FPGA-02/F2_B14_U14: U11.U14 (IO_L22P_T3_A05_D21_14); also elsewhere on the board
/FPGA-02/F2_B14_U16: U11.U16 (IO_L18P_T2_A12_D28_14); also elsewhere on the board
/FPGA-02/F2_B14_V14: U11.V14 (IO_L22N_T3_A04_D20_14); also elsewhere on the board
/FPGA-02/F2_B14_V15: U11.V15 (IO_L16P_T2_CSI_B_14); also elsewhere on the board
/FPGA-02/F2_B14_V16: U11.V16 (IO_L16N_T2_A15_D31_14); also elsewhere on the board
/FPGA-02/F2_B14_V17: U11.V17 (IO_L18N_T2_A11_D27_14); also elsewhere on the board
/SCK_FLASH_uC: U11.L18 (IO_L4P_T0_D04_14); also elsewhere on the board
/SI_FLASH_FPGA2: U11.K17 (IO_L1P_T0_D00_MOSI_14); also elsewhere on the board
/SI_FLASH_uC: U11.J18 (IO_L23N_T3_FWE_B_15); also elsewhere on the board
/SO_FLASH_FPGA2: U11.K18 (IO_L1N_T0_D01_DIN_14); also elsewhere on the board
/SO_FLASH_uC: U11.J17 (IO_L23P_T3_FOE_B_15); also elsewhere on the board
GND: C195.2, C326.2, C327.2, C328.2, C329.2, C330.2, C331.2, C332.2, C333.2, C334.2, C335.2, C336.2, C337.2, C338.2, C339.2, D22.1 (K), D23.1 (K); also elsewhere on the board
unnamed: D22.2 (A), R146.2
unnamed: D23.2 (A), R147.2
unnamed: R147.1, U11.U11 (IO_L19N_T3_A09_D25_VREF_14)
unnamed: R146.1, U11.U12 (IO_L20P_T3_A08_D24_14)

Notes on the sheet:
DEBUG LEDs

Schematic: FPGA1_BANK14-15.kicad_sch, RASBB

Parts:
C188: 47uF; C_0805_2012Metric; Mfr. Part # GRM21BR61A476ME15L; LCSC Part # C124129
C233, C234, C235, C236, C239, C241, C242, C243, C244, C245, C251, C252, C253, C254, C255, C257: 470nF; C_0402_1005Metric; Mfr. Part # GRT155R71A474KE01D; LCSC Part # C471404
C246, C247, C249, C250: 4.7uF; C_0402_1005Metric; Mfr. Part # GRM155R61A475KEAAD; LCSC Part # C77004
C248: 100uF; C_1206_3216Metric; Mfr. Part # GRM31CR61A107MEA8L; LCSC Part # C883598
D24: A-SP192GS1D-C01-4T; LED_0603_1608Metric; Mfr. Part # A-SP192GS1D-C01-4T; LCSC Part # C5355434
D25: A-SP192DGHC-C01-4T; LED_0603_1608Metric; Mfr. Part # A-SP192DGHC-C01-4T; LCSC Part # C19171301
R148, R149: 1K; R_0402_1005Metric; Mfr. Part # MR04X1001FTL; LCSC Part # C327796
U10: XC7A100T-CSG324; BGA324C80P18X18_1500X1500X150; Mfr. Part # XC7A100T-2CSG324I; LCSC Part # C1521791

Connections:
+3V3: C188.2, C233.1, C234.1, C235.1, C236.1, C239.1, C241.1, C242.1, C243.1, C244.1, C245.1, C246.1, C247.1, C248.1, C249.1, C250.1, C251.1, C252.1, C253.1, C254.1, C255.1, C257.1, U10.A17 (VCCO_15), U10.C13 (VCCO_15), U10.D16 (VCCO_15), U10.G15 (VCCO_15), U10.H18 (VCCO_15), U10.K14 (VCCO_15), U10.L17 (VCCO_14), U10.N13 (VCCO_14), U10.P16 (VCCO_14), U10.T12 (VCCO_14), U10.U15 (VCCO_14), U10.V18 (VCCO_14); also elsewhere on the board
/CLK_OVR_ETH: U10.G18 (IO_L22P_T3_A17_15); also elsewhere on the board
/CS_FLASH_uC: U10.E18 (IO_L21P_T3_DQS_15); also elsewhere on the board
/Config-SPI FLASH/CS_Flash_FPGA1: U10.L13 (IO_L6P_T0_FCS_B_14); also elsewhere on the board
/DEBUG_A0_F: U10.N17 (IO_L9P_T1_DQS_14); also elsewhere on the board
/DEBUG_A1_F: U10.R15 (IO_L13N_T2_MRCC_14); also elsewhere on the board
/DEBUG_A2_F: U10.P18 (IO_L9N_T1_DQS_D13_14); also elsewhere on the board
/DEBUG_A3_F: U10.R16 (IO_L15P_T2_DQS_RDWR_B_14); also elsewhere on the board
/DEBUG_A4_F: U10.P17 (IO_L12P_T1_MRCC_14); also elsewhere on the board
/DEBUG_A5_F: U10.P15 (IO_L13P_T2_MRCC_14); also elsewhere on the board
/DEBUG_A6_F: U10.R18 (IO_L7P_T1_D09_14); also elsewhere on the board
/DEBUG_A7_F: U10.N14 (IO_L8P_T1_D11_14); also elsewhere on the board
/DEBUG_D0_F: U10.R17 (IO_L12N_T1_MRCC_14); also elsewhere on the board
/DEBUG_D1_F: U10.N16 (IO_L11N_T1_SRCC_14); also elsewhere on the board
/DEBUG_D2_F: U10.T18 (IO_L7N_T1_D10_14); also elsewhere on the board
/DEBUG_D3_F: U10.N15 (IO_L11P_T1_SRCC_14); also elsewhere on the board
/DEBUG_D4_F: U10.U18 (IO_L17N_T2_A13_D29_14); also elsewhere on the board
/DEBUG_D5_F: U10.M16 (IO_L10P_T1_D14_14); also elsewhere on the board
/DEBUG_D6_F: U10.U17 (IO_L17P_T2_A14_D30_14); also elsewhere on the board
/DEBUG_D7_F: U10.M17 (IO_L10N_T1_D15_14); also elsewhere on the board
/DEBUG_D8_F: U10.V17 (IO_L18N_T2_A11_D27_14); also elsewhere on the board
/DEBUG_D9_F: U10.L18 (IO_L4P_T0_D04_14); also elsewhere on the board
/DEBUG_D10_F: U10.U16 (IO_L18P_T2_A12_D28_14); also elsewhere on the board
/DEBUG_D11_F: U10.M18 (IO_L4N_T0_D05_14); also elsewhere on the board
/DEBUG_D12_F: U10.V16 (IO_L16N_T2_A15_D31_14); also elsewhere on the board
/DEBUG_D13_F: U10.M14 (IO_L2N_T0_D03_14); also elsewhere on the board
/DEBUG_D14_F: U10.V15 (IO_L16P_T2_CSI_B_14); also elsewhere on the board
/DEBUG_D15_F: U10.T10 (IO_L24N_T3_A00_D16_14); also elsewhere on the board
/DEBUG_D16_F: U10.U14 (IO_L22P_T3_A05_D21_14); also elsewhere on the board
/DEBUG_D17_F: U10.T11 (IO_L19P_T3_A10_D26_14); also elsewhere on the board
/DEBUG_D18_F: U10.V14 (IO_L22N_T3_A04_D20_14); also elsewhere on the board
/DEBUG_D19_F: U10.R12 (IO_L5P_T0_D06_14); also elsewhere on the board
/DEBUG_D20_F: U10.U13 (IO_L23N_T3_A02_D18_14); also elsewhere on the board
/DEBUG_D21_F: U10.T13 (IO_L23P_T3_A03_D19_14); also elsewhere on the board
/DEBUG_D22_F: U10.U12 (IO_L20P_T3_A08_D24_14); also elsewhere on the board
/DEBUG_D23_F: U10.R13 (IO_L5N_T0_D07_14); also elsewhere on the board
/DEBUG_D24_F: U10.V10 (IO_L21P_T3_DQS_14); also elsewhere on the board
/DEBUG_D25_F: U10.T14 (IO_L14P_T2_SRCC_14); also elsewhere on the board
/DEBUG_D26_F: U10.V11 (IO_L21N_T3_DQS_A06_D22_14); also elsewhere on the board
/DEBUG_D27_F: U10.P14 (IO_L8N_T1_D12_14); also elsewhere on the board
/DEBUG_D28_F: U10.U11 (IO_L19N_T3_A09_D25_VREF_14); also elsewhere on the board
/DEBUG_D29_F: U10.T15 (IO_L14N_T2_SRCC_14); also elsewhere on the board
/DEBUG_D30_F: U10.V12 (IO_L20N_T3_A07_D23_14); also elsewhere on the board
/DEBUG_D31_F: U10.T16 (IO_L15N_T2_DQS_DOUT_CSO_B_14); also elsewhere on the board
/FPGA1_RESET: U10.F18 (IO_L22N_T3_A16_15); also elsewhere on the board
/FPGA-01/F1_B15_A13: U10.A13 (IO_L9P_T1_DQS_AD3P_15); also elsewhere on the board
/FPGA-01/F1_B15_A14: U10.A14 (IO_L9N_T1_DQS_AD3N_15); also elsewhere on the board
/FPGA-01/F1_B15_A15: U10.A15 (IO_L8P_T1_AD10P_15); also elsewhere on the board
/FPGA-01/F1_B15_A16: U10.A16 (IO_L8N_T1_AD10N_15); also elsewhere on the board
/FPGA-01/F1_B15_A18: U10.A18 (IO_L10N_T1_AD11N_15); also elsewhere on the board
/FPGA-01/F1_B15_B16: U10.B16 (IO_L7P_T1_AD2P_15); also elsewhere on the board
/FPGA-01/F1_B15_B17: U10.B17 (IO_L7N_T1_AD2N_15); also elsewhere on the board
/FPGA-01/F1_B15_B18: U10.B18 (IO_L10P_T1_AD11P_15); also elsewhere on the board
/FPGA-01/F1_B15_C15: U10.C15 (IO_L12N_T1_MRCC_15); also elsewhere on the board
/FPGA-01/F1_B15_D15: U10.D15 (IO_L12P_T1_MRCC_15); also elsewhere on the board
/FPGA-01/F1_B15_E15: U10.E15 (IO_L11P_T1_SRCC_15); also elsewhere on the board
/FPGA-01/F1_B15_E16: U10.E16 (IO_L11N_T1_SRCC_15); also elsewhere on the board
/FPGA-01/FPGA1_MISO: U10.K18 (IO_L1N_T0_D01_DIN_14); also elsewhere on the board
/FPGA-01/FPGA1_MOSI: U10.K17 (IO_L1P_T0_D00_MOSI_14); also elsewhere on the board
/SCK_FLASH_uC: U10.D18 (IO_L21N_T3_DQS_A18_15); also elsewhere on the board
/SI_FLASH_uC: U10.E17 (IO_L16P_T2_A28_15); also elsewhere on the board
/SO_FLASH_uC: U10.D17 (IO_L16N_T2_A27_15); also elsewhere on the board
GND: C188.1, C233.2, C234.2, C235.2, C236.2, C239.2, C241.2, C242.2, C243.2, C244.2, C245.2, C246.2, C247.2, C248.2, C249.2, C250.2, C251.2, C252.2, C253.2, C254.2, C255.2, C257.2, D24.1 (K), D25.1 (K); also elsewhere on the board
unnamed: D24.2 (A), R148.2
unnamed: D25.2 (A), R149.2
unnamed: R148.1, U10.B14 (IO_L2N_T0_AD8N_15)
unnamed: R149.1, U10.B13 (IO_L2P_T0_AD8P_15)

Notes on the sheet:
DEBUG LEDs

Schematic: FPGA1_BANK16-34.kicad_sch, RASBB

Parts:
C75, C224, C229, C230, C231, C232: 470nF; C_0402_1005Metric; Mfr. Part # GRT155R71A474KE01D; LCSC Part # C471404
C223, C227, C228: 4.7uF; C_0402_1005Metric; Mfr. Part # GRM155R61A475KEAAD; LCSC Part # C77004
C226: 100uF; C_1206_3216Metric; Mfr. Part # GRM31CR61A107MEA8L; LCSC Part # C883598
U10: XC7A100T-CSG324; BGA324C80P18X18_1500X1500X150; Mfr. Part # XC7A100T-2CSG324I; LCSC Part # C1521791

Connections:
+1V8: C223.1, C224.1, U10.B10 (VCCO_16); also elsewhere on the board
+1V35: C75.1, C226.1, C227.1, C228.1, C229.1, C230.1, C231.1, C232.1, U10.K4 (VCCO_34), U10.N3 (VCCO_34), U10.P6 (VCCO_34), U10.T2 (VCCO_34), U10.U5 (VCCO_34), U10.V8 (VCCO_34); also elsewhere on the board
/DDR3-01/CK_N: U10.V9 (IO_L21N_T3_DQS_34); also elsewhere on the board
/DDR3-01/CK_P: U10.U9 (IO_L21P_T3_DQS_34); also elsewhere on the board
/DDR3-01/DDR301_A0: U10.R2 (IO_L15N_T2_DQS_34); also elsewhere on the board
/DDR3-01/DDR301_A1: U10.M6 (IO_L18P_T2_34); also elsewhere on the board
/DDR3-01/DDR301_A2: U10.N4 (IO_L16N_T2_34); also elsewhere on the board
/DDR3-01/DDR301_A3: U10.T1 (IO_L17N_T2_34); also elsewhere on the board
/DDR3-01/DDR301_A4: U10.N6 (IO_L18N_T2_34); also elsewhere on the board
/DDR3-01/DDR301_A5: U10.R7 (IO_L23P_T3_34); also elsewhere on the board
/DDR3-01/DDR301_A6: U10.V6 (IO_L20N_T3_34); also elsewhere on the board
/DDR3-01/DDR301_A7: U10.U7 (IO_L22P_T3_34); also elsewhere on the board
/DDR3-01/DDR301_A8: U10.R8 (IO_L24P_T3_34); also elsewhere on the board
/DDR3-01/DDR301_A9: U10.V7 (IO_L20P_T3_34); also elsewhere on the board
/DDR3-01/DDR301_A10/AP: U10.R6 (IO_L19P_T3_34); also elsewhere on the board
/DDR3-01/DDR301_A11: U10.U6 (IO_L22N_T3_34); also elsewhere on the board
/DDR3-01/DDR301_A12/nBC: U10.T6 (IO_L23N_T3_34); also elsewhere on the board
/DDR3-01/DDR301_A13: U10.T8 (IO_L24N_T3_34); also elsewhere on the board
/DDR3-01/DDR301_A14: U10.T5 (IO_L12P_T1_MRCC_34); also elsewhere on the board
/DDR3-01/DDR301_BA0: U10.R1 (IO_L17P_T2_34); also elsewhere on the board
/DDR3-01/DDR301_BA1: U10.P4 (IO_L14P_T2_SRCC_34); also elsewhere on the board
/DDR3-01/DDR301_BA2: U10.P2 (IO_L15P_T2_DQS_34); also elsewhere on the board
/DDR3-01/DDR301_CLKE: U10.N5 (IO_L13P_T2_MRCC_34); also elsewhere on the board
/DDR3-01/DDR301_DQ0: U10.K5 (IO_L5P_T0_34); also elsewhere on the board
/DDR3-01/DDR301_DQ1: U10.L3 (IO_L2N_T0_34); also elsewhere on the board
/DDR3-01/DDR301_DQ2: U10.K3 (IO_L2P_T0_34); also elsewhere on the board
/DDR3-01/DDR301_DQ3: U10.L6 (IO_L6P_T0_34); also elsewhere on the board
/DDR3-01/DDR301_DQ4: U10.M3 (IO_L4P_T0_34); also elsewhere on the board
/DDR3-01/DDR301_DQ5: U10.M1 (IO_L1N_T0_34); also elsewhere on the board
/DDR3-01/DDR301_DQ6: U10.L4 (IO_L5N_T0_34); also elsewhere on the board
/DDR3-01/DDR301_DQ7: U10.M2 (IO_L4N_T0_34); also elsewhere on the board
/DDR3-01/DDR301_DQ8: U10.V4 (IO_L10N_T1_34); also elsewhere on the board
/DDR3-01/DDR301_DQ9: U10.T4 (IO_L12N_T1_MRCC_34); also elsewhere on the board
/DDR3-01/DDR301_DQ10: U10.U4 (IO_L8P_T1_34); also elsewhere on the board
/DDR3-01/DDR301_DQ11: U10.V5 (IO_L10P_T1_34); also elsewhere on the board
/DDR3-01/DDR301_DQ12: U10.V1 (IO_L7N_T1_34); also elsewhere on the board
/DDR3-01/DDR301_DQ13: U10.T3 (IO_L11N_T1_SRCC_34); also elsewhere on the board
/DDR3-01/DDR301_DQ14: U10.U3 (IO_L8N_T1_34); also elsewhere on the board
/DDR3-01/DDR301_DQ15: U10.R3 (IO_L11P_T1_SRCC_34); also elsewhere on the board
/DDR3-01/DDR301_LDM: U10.L1 (IO_L1P_T0_34); also elsewhere on the board
/DDR3-01/DDR301_LDQS_N: U10.N1 (IO_L3N_T0_DQS_34); also elsewhere on the board
/DDR3-01/DDR301_LDQS_P: U10.N2 (IO_L3P_T0_DQS_34); also elsewhere on the board
/DDR3-01/DDR301_ODT: U10.R5 (IO_L19N_T3_VREF_34); also elsewhere on the board
/DDR3-01/DDR301_UDM: U10.U1 (IO_L7P_T1_34); also elsewhere on the board
/DDR3-01/DDR301_UDQS_N: U10.V2 (IO_L9N_T1_DQS_34); also elsewhere on the board
/DDR3-01/DDR301_UDQS_P: U10.U2 (IO_L9P_T1_DQS_34); also elsewhere on the board
/DDR3-01/DDR301_nCAS: U10.M4 (IO_L16P_T2_34); also elsewhere on the board
/DDR3-01/DDR301_nCS: U10.U8 (IO_25_34); also elsewhere on the board
/DDR3-01/DDR301_nRAS: U10.P3 (IO_L14N_T2_SRCC_34); also elsewhere on the board
/DDR3-01/DDR301_nRST: U10.K6 (IO_0_34); also elsewhere on the board
/DDR3-01/DDR301_nWE: U10.P5 (IO_L13N_T2_MRCC_34); also elsewhere on the board
GND: C75.2, C223.2, C224.2, C226.2, C227.2, C228.2, C229.2, C230.2, C231.2, C232.2; also elsewhere on the board

Notices in the files:
RASBB/Hardware/Rev.C/Design/RASBB.kicad_pcb:
Licensed under CERN-OHL-S-2.0
